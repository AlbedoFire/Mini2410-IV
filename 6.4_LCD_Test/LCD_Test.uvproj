# Keil uVision project LCD_Test.uvproj, settings and files
target LCD_Test IN RAM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: LCD_Test
  c flags: Optim=4
  c include: ..\Common\Inc;.\Include
  memory RVCT1: ROM 0x30000000 size 0x200000
  memory RVCT6: RAM 0x30200000 size 0x4000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group Startup
    ./: S3C2410A.s
  group Source
    ./Source/: ascii6x8.c ascii8x16.c glib.c lcd.c lcdlib.c main.c hzk24.c color_lcd_test.c led16x16.c hzk24s.c fonts.c Dotled.c
  group Common
    ../common/src/: 2410lib.c sys_init.c
  group IniFile
    ./: SDRAM.ini
  group ReadMe
    ./: readme.txt
target LCD_Test IN FLASH (ARM-ADS)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: LCD_Test +hex
  c flags: Optim=1
  c include: ..\Common\Inc;.\Include
  memory RVCT1: ROM 0x0 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x4000000
  memory RVCT9: RAM 0x40000000 size 0x1000
